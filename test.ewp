# IAR project test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F40_41xxx; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: Libraries\CMSIS\Device\ST\STM32F4xx\Include; Libraries\CMSIS\Include; Libraries; Libraries\Libraries\STM32F4xx_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: test.hex
  ILINK.IlinkOutputFile: test.out
  ILINK.IlinkIcfFile: Libraries\stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    Libraries/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group EWARM
    Libraries/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40_41xxx.s
  group GUI
    마이컴구조_FRAM 실습자료/마이컴구조_FRAM 실습자료/: FRAM.c
    Libraries/Libraries/: GLCD.c GuiObject.c Gulim10_8x16_ASCII.c Gulim20_16x34_ASCII.c Gulim28_24x48_ASCII.c Gulim7_6x10_ASCII.c Gulim8_8x12_ASCII.c ILI9163B.c
  group HAL
    Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_gpio.c stm32f4xx_hal_tim.c
    Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal_gpio.h stm32f4xx_hal_tim.h stm32f4xx_ll_gpio.h stm32f4xx_ll_tim.h
  group STM32F4xx_StdPeriph_Driver
    Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_fsmc.c stm32f4xx_iwdg.c stm32f4xx_spi.c
    Libraries/Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c
  group User
    ./: 3_HW1_2019130027_유정환.c 3_HW2_2019130027_xxxx1학기.c 3_HW2_2019130027_유정환.c 3_HW2_2019130027_유정환1학기.c 3_HW3_2019130027_유정환.c 3_HW3_2019130027_유정환1학기.c 3_PR1_2019130027_유정환.c 3_TP1_2019130027_유정환1학기.c 3_TP2_2019130027_1학기.c 55555555555555555555.c ADC3_채널테스트.c ADC_2CH_DistSensor_VR.c ADC_Interrupt.c ADC_Interrupt_DistSensor.c ADC_Interrupt_TRIG(EXTI11).c ADC_Interrupt_TRIG(TIM5CH3).c ADC_Interrupt_TRIG(TIM5CH3)_student.c ADC_Polling.c ADC_SCAN_2ch(DMA))_원본.c ADC_SCAN_2ch(DMA).c ADC_SCAN_2ch(NO DMA).c DMA_main.c EXTINT(Student).c EXTINT(Student)_답지 - 복사본.c EXTINT(Student)_답지.c EXTINT_Priority.c GLCD_Display(Char_Draw).c GLCD_Display.c GPIO_JoyStick(Student).c GPIO_KeyScan(student).c GPIO_LED.c GPIO_SW(Student).c IWDGT main.c sasdqweqw.c SPI_g.c SPI_g_과제.......................c T5CH1PWM_T4Ch1Ch2Encoder(student).c T5CH1PWM_T4Ch1Ch2Encoder_빈칸채워진원본.c T5CH1PWM_T4Ch1Counter(RPM) - 복사본.c T5CH1PWM_T4Ch1Counter(RPM).c T5CH1PWM_T4Ch1Counter.c TIM1_OCmode(Step).c TIM3_UpCounting(1ms INT).c TIM3_UpCounting(1ms INT)_원본.c TIM3_Updown test - .c TIM4_OCmode.c TIM4_OCmode_원본.c TIM4_PWM_T4CH3(PB8).c TIM5_DownCounting(2s INT).c TIM5_DownCounting(2s INT)_수업921.c USART_RX_INT.c USART_RX_INT_4(BT)_ADR.c USART_RX_INT_test.c USART_RX_INT_원본.c USART_RX_TX_INT.c 기말공부.c 시계 과제 중 - 복사본.c 시계 과제 중.c 타이머테스트.c 텀프1_연습.c 텀프1_하는중.c 텀프2_연습.c 텀프테스트.c
    Libraries/: ACC.c
    마이컴구조_FRAM 실습자료/마이컴구조_FRAM 실습자료/: FRAM_main.c
    Libraries/Libraries/: Util.c
